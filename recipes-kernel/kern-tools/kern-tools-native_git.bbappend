# Update kern tools to add support for transitional flag

SRCREV = "a4a362d9f4f0abc8ab145a8673166b9bd875731a"
